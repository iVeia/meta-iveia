# Use a more reliable SRC_URI
SRC_URI="http://petalinux.xilinx.com/sswreleases/rel-v2018.3/sources/x86_64-linux/dev86-native-${PV}-${PR}/Dev86src-${PV}.tar.gz"
