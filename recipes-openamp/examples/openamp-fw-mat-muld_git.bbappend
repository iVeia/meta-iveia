require xsct-workaround.inc

