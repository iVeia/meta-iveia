require xsct-workaround.inc
