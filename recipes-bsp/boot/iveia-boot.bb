SUMMARY = "Generates boot.bin using bootgen tool"

LICENSE = "CLOSED"

DEPENDS += "iveia-boot-fsbl2uboot iveia-boot-fsbl2sd u-boot-uenv"

