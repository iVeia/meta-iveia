DEPENDS_remove += "virtual/boot-bin"
EXTRA_IMAGEDEPENDS_remove += "virtual/boot-bin"

