inherit switch-uart
SWITCH_UART_00126 := "0"
XPARAMETERS_H = "${B}/pmu-firmware/zynqmp_pmufw_bsp/psu_pmu_0/include/xparameters.h"

