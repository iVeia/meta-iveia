inherit switch-uart
XPARAMETERS_H = "${B}/pmu-firmware/zynqmp_pmufw_bsp/psu_pmu_0/include/xparameters.h"
