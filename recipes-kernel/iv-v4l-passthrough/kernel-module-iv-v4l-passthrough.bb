SUMMARY = "iVeia V4L Passthrough Dummy Driver"
inherit kernel-module
