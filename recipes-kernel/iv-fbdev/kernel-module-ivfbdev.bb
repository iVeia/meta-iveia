SUMMARY = "iVeia Framebuffer driver"
inherit kernel-module
