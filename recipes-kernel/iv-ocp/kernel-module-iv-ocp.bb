SUMMARY = "iVeia OCP driver"
inherit kernel-module
