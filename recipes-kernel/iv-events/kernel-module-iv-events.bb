SUMMARY = "iVeia Events driver"
inherit kernel-module
