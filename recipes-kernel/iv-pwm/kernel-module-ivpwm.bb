SUMMARY = "iVeia PWM driver"
inherit kernel-module
