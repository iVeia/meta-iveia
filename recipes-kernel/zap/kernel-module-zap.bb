SUMMARY = "iVeia ZAP driver"
inherit kernel-module
