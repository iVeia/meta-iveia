IMAGE_TYPE = "minimal"
require ivinstall.inc
