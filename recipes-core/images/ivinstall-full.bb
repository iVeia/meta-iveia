IMAGE_TYPE = "full"
require ivinstall.inc
